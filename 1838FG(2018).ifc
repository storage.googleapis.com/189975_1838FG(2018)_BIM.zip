Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-12T13:53:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 13:53:05 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{848FE464-F95A-499C-92FA-6D3E54153E8A}\ifc * Database version: 5507 * Database creation date: Wed Jun 12 13:53:05 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 13:53:05 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 13:53:05 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1838FG Kitchen faucet, 1838FG(2018):1838FG Kitchen faucet:337287
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 261.355 mm; NominalHeight: 338.07 mm; NominalWidth: 53.7296 mm; Projection: 178 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1838FG(2018); ConvergoRefNr: 0087-1906-0041-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 11/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150089596; EN Standard: EN 817; LVI Number: 6219148; Noise Class: I (ISO 3822); RSK Number: 8310966
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1838FG; Catalog Drawing URL: http://static.oras.com/catdrw/1838FG; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1838FG; FDV Document URL: http://www.oras.com/datasheet/1838FG/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1838FG; Group: Kitchen faucets; Long Marketing: Kitchen faucet with high spout. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 0° or 60°). Lever is equipped with an eco-button for limiting flow-rate, which can be bypassed by pressing the button. With flexible pipes.; Manufacturer: Oras; Market: INT;FIN;SWE;POL;EST;LTU;LVA;UKR; Model: 1838FG Kitchen faucet; Name_en: 1838FG Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 754 x 334 x 63; Package Weight: 2.05 kg; Product Code: 1838FG; Product Datasheet: http://www.oras.com/datasheet/1838FG/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1838FG; Product URL: http://static.oras.com/1838FG; Type Name: 1838FG Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Eco Flow At 300kPa: 0.0052972 m3/s; Flow Rate At 300kPa: 0.00953496 m3/s; Installation and Maintenance: http://static.oras.com/manual/1838FG; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 170000 Pa; Spare Parts: http://static.oras.com/sp/1838FG; Spout Type: Swivel spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1838FG(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1838FG; Name: 1838FG Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 55x260x340 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1838FG; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1838FG Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.121663 m2; Volume: 0.00475205 m3
Identity Data - Mark: 9
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1838FG(2018): 1838FG Kitchen faucet; Family and Type: 1838FG(2018): 1838FG Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1838FG(2018): 1838FG Kitchen faucet; Type Id: 1838FG(2018): 1838FG Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
